!Agilent Technologies,N5230A,MY45001650,A.07.50.48
!Agilent N5230A: A.07.50.48
!Date: Wednesday, April 30, 2014 16:44:48
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   1500 points, 10 MHz to 15 GHz, reference 50 ohm
!   highest |S21| = -28.97 dB at 13.98 GHz (marker M1); lowest = -80.5 dB at 110 MHz (marker M2)
!   lowest |S11| = -22.4 dB at 2.44 GHz (marker M3), VSWR 1.17, Z = 43.3 + j2.55 ohm
!   |S11| at or under -10 dB: 39.46 MHz to 3.875 GHz (3.835 GHz wide, 196 % of centre); 14.99815 GHz to end of sweep
!   |S22| runs from -23.6 to -0.1 dB; largest |S21 - S12| = 0.0041
!   the Smith chart shows 10 MHz to 8.33 GHz only
!   S11 on the Smith chart (normalised r, x): 10 MHz: 1.12, -2.74; 1.5 GHz: 0.89, -0.18; 4.55 GHz: 1.68, -1.01; 6.35 GHz: 0.45, -0.15; 7.36 GHz: 0.43, +0.80; 8.33 GHz: 1.85, +3.24
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -2.0  -54.0  -52.3  -0.1
! 110 MHz  -17.3  -80.5  -58.2  -2.0
! 330 MHz  -21.1  -54.7  -55.7  -8.2
! 1.02 GHz  -19.5  -46.0  -46.1  -22.5
! 1.5 GHz  -19.1  -42.6  -42.8  -20.3
! 2.44 GHz  -22.4  -39.0  -39.0  -13.5
! 2.51 GHz  -22.1  -38.8  -38.8  -13.2
! 4.55 GHz  -7.4  -35.3  -35.4  -11.1
! 5.01 GHz  -7.2  -34.9  -34.9  -10.2
! 6.35 GHz  -8.1  -32.8  -32.8  -6.7
! 7.36 GHz  -4.5  -32.1  -32.1  -6.5
! 7.51 GHz  -4.0  -32.1  -32.1  -6.6
! 8.33 GHz  -2.2  -33.2  -33.3  -7.5
! 9.66 GHz  -2.7  -40.4  -40.3  -9.6
! 10.01 GHz  -3.1  -35.8  -35.8  -8.8
! 10.75 GHz  -3.6  -32.1  -31.9  -6.1
! 12.51 GHz  -1.7  -34.0  -34.3  -6.3
! 12.76 GHz  -1.8  -53.0  -56.4  -8.1
! 12.96 GHz  -1.7  -33.2  -33.3  -7.9
! 13.61 GHz  -1.7  -29.3  -29.4  -22.5
! 13.98 GHz  -1.9  -29.0  -29.3  -11.3
! 15 GHz  -10.0  -31.5  -31.7  -3.4
